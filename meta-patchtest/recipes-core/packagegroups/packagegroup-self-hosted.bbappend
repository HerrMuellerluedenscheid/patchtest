RDEPENDS_packagegroup-self-hosted-extended += "\
    openssh-scp \
    openssh-ssh \
    perl-misc \
"